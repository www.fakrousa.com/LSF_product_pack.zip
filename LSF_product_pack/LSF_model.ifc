Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
Time: 2023-01-23T15:47:43
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.5.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 ft
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1582
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: AtticStairs_Fakro_LSF:70x110, AtticStairs_Fakro_LSF:70x110:105023
In: Level 1
Type - Material: beżowe (62), bezowe (65), biały, bialy
Type - Constraints - Default Elevation: 0 ft
Type - Identity Data - Type Name: 70x110
Type - Other - Category: Generic Models; Box lenght: 3.60892 ft; Box width: 2.29659 ft; Family Name: AtticStairs_Fakro_LSF; Hatch lenght: 3.48425 ft; Ladder width: 1.3878 ft
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: 70x110; sets with these values: 2
Constraints - Moves With Nearby Elements: no
Dimensions - Area: 29.9041 ft2; Volume: 1.83923 ft3
Other - Family: AtticStairs_Fakro_LSF; Family and Type: AtticStairs_Fakro_LSF: 70x110; Host Id: 105013; Type: 70x110; Type Id: 104989
Phasing - Phase Created: New Construction
